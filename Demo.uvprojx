# Keil uVision project Demo.uvprojx, settings and files
target Targets (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\App;.\Bsp;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;.\uCOS-II\Source;.\HardWare\SR_04;.\HardWare\usart;.\HardWare\delay;.\HardWare\sys;.\L298N
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Bsp
    ./Bsp/: bsp.c
  group uC/OS-II Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC/OS-II Ports
    ./uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group App
    ./App/: main.c app_task.c stm32f10x_it.c
  group Doc
    ./Doc/: ReadMe.txt
  group HardWare
    ./HardWare/SR_04/: SR_04.c
    ./HardWare/delay/: delay.c
    ./HardWare/usart/: usart.c
    ./HardWare/sys/: sys.c
    ./L298N/: motor.c PWM.c
